# IAR project BOOTLOADER-LIP.ewp, settings and files
configuration LIP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091CC ST STM32F091CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\CMSIS\CM0\DeviceSupport\ST\STM32F0x; ..\\STM32F0xx_StdPeriph_Driver\inc; ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: BOOTLOADER-LIP.hex
  ILINK.IlinkOutputFile: CHG.CTRL.CPU.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../CMSIS/CM0/DeviceSupport/ST/STM32F0x/: system_stm32f0xx.c
  group EWARMv5
    ../CMSIS/CM0/DeviceSupport/ST/STM32F0x/startup/iar/: startup_stm32f091xc.s
  group StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: bootloader.cpp crc16.c id.c init.c main.cpp memutil.c ramdata.c stm32f0xx_it.c
  group User/modbus
    ../modbus/: modbus.c uart1rs485.c
