# IAR project LIP.ewp, settings and files
configuration LIP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\STM32F10x_StdPeriph_Driver\inc; ..\; ..\Drivers\Communications; ..\Drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: LIP.hex
  ILINK.IlinkOutputFile: CHG.CTRL.CPU.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EWARMv5
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../: app_check_info.c Buffer.cpp crc16.c DMAIndicator.cpp flashdata.c id.c init.c livecontrol.c main.cpp memutil.c ramdata.c SPI.cpp stm32f10x_it.c utils.cpp
  group User/DevicePollManager
    ../DevicePollManager/: DevicePollManager.cpp Slot.cpp
  group User/Drivers
    ../Drivers/: STM32F10x_Intmash_USART.c
  group User/Drivers/Communications
    ../Drivers/Communications/: com_master_driver.cpp
  group User/Indicator
    ../Indicator/: Indicator.cpp LIP_5Nx.cpp
  group User/ini
    ../ini/: parser.cpp
  group User/modbus
    ../modbus/: modbus.c ModbusMasterConf.cpp STM32F10xUSART2.cpp uart1rs485.c
  group User/Msg
    ../Msg/: msg.cpp
  group User/Page
    ../Page/: Page.cpp
  group User/Parameters
    ../Parameters/: GeneralCaseSignal.cpp Parameter.cpp ParametersUtils.cpp scaleutils.cpp signal.cpp TFloat.cpp TS16BIT.cpp TU16BIT.cpp TU32BIT.cpp
  group User/Router
    ../Router/: Router.cpp
