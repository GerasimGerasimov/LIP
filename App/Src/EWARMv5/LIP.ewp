# IAR project LIP.ewp, settings and files
configuration LIP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091CC ST STM32F091CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\CMSIS\CM0\DeviceSupport\ST\STM32F0x; ..\\STM32F0xx_StdPeriph_Driver\inc; ..\; ..\MCU; ..\Drivers; ..\Drivers\Communications
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: LIP.hex
  ILINK.IlinkOutputFile: CHG.CTRL.CPU.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../CMSIS/CM0/DeviceSupport/ST/STM32F0x/: system_stm32f0xx.c
  group Drivers
    ../Drivers/: KeyBoardUpdate.cpp STM32F0xx_Intmash_USART.c
  group Drivers/Communications
    ../Drivers/Communications/: com_master_driver.cpp
  group Drivers/Resources
    ../Drivers/Resources/: os_resources.cpp
  group EWARMv5
    ../CMSIS/CM0/DeviceSupport/ST/STM32F0x/startup/iar/: startup_stm32f091xc.s
  group MCU
    ../MCU/: crc16.c
  group MCU/App
    ../MCU/App/: App.cpp
  group MCU/Buffer
    ../MCU/Buffer/: Buffer.cpp
  group MCU/DevicePollManager
    ../MCU/DevicePollManager/: DevicePollManager.cpp Devices.cpp Slot.cpp
  group MCU/Helpers
    ../MCU/Helpers/: utils.cpp
  group MCU/Indicator
    ../MCU/Indicator/: ControlIndicatorSlot.cpp ControlIndicatorSlot.h Indicator.cpp Indicator1Parametr.cpp LIP_5Nx.cpp LIP_SS8.cpp LIP_SS8_Bl_2R.cpp LIP_SS8_Bl_2R.h
  group MCU/ini
    ../MCU/ini/: IniResources.cpp parser.cpp
  group MCU/Message
    ../MCU/Message/: Message.cpp
  group MCU/Page
    ../MCU/Page/: Page.cpp
  group MCU/Parameters
    ../MCU/Parameters/: GeneralCaseSignal.cpp IniString.cpp Parameter.cpp ParametersUtils.cpp Scale.cpp scaleutils.cpp signal.cpp SignalFactoty.cpp TBit.cpp TFloat.cpp TPrmList.cpp TS16BIT.cpp TU16BIT.cpp TU32BIT.cpp TU8BIT.cpp
  group MCU/Resources
    ../MCU/Resources/: InternalResources.cpp
  group MCU/Router
    ../MCU/Router/: Router.cpp
  group MCU/Slots
    ../MCU/Slots/: HandlerSlotRead.cpp ParametrControlSlot.cpp ParametrControlSlotXN.cpp ParametrControlSlotXN.h SlotHandlerType.h
  group StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: app_check_info.c DMAIndicator.cpp flashdata.c id.c init.c livecontrol.c main.cpp memutil.c ramdata.c stm32f0xx_it.c
  group User/modbus
    ../modbus/: modbus.c ModbusMasterConf.cpp STM32F0xxUSART2.cpp uart1rs485.c
